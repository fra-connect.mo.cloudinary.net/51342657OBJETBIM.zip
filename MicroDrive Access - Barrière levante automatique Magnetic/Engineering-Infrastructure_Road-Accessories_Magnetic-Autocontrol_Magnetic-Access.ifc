Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Engineering-Infrastructure_Road-Accessories_Magnetic-Autocontrol_Magnetic-Access.ifc
Time: 2022-04-26T11:11:18
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcProxy, Magnetic Access
ePset_BIMobjectScript - SIZE: MIN; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Magnetic Access; SKU (BO_prodsku): Magnetic-Access; ManufacturName (BO_Manufac): Magnetic Autocontrol; BrandUrl (BO_brandurl): http://www.magnetic-access.com/; ProductFamily (BO_prodfam): MHTM MicroDrive; ProductGroup (BO_prodgroup): Access; ManufacturCountry (BO_mancont): Germany; DesignCountry (BO_designcont): Germany; PublishDate (BO_publisdat): 12/6/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 360; Height (BO_height): 915; Depth (BO_depth): 315; Weight (BO_weight): 40; QR (BO_boqrurl): http://bimobject.com/magnetic-autocontrol/product/Magnetic-Access; ProductDataUrl (BO_prodaturl): bimobject.com/magnetic-autocontrol/product/Magnetic-Access; ProductUrl (BO_producturl): https://www.magnetic-access.com/en/products/barriers/access/access.html; ProductCertification (BO_prodcert): https://www.magnetic-access.com/en/downloads/certificates.html; TechnicalDescription (BO_techcert): https://www.magnetic-access.com/files/data-DE/datenblaetter/DB_Access_en.pdf; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=UhrqRGPXxCg; MaterialMain (BO_mainmat): Aluminium; MaterialSecondary (BO_secmat): Steel; BimObjectMainCategory (BO_bomaincat): Engineering & Infrastructure; BimObjectMainCategoryCode (BO_bomaincat_code): engineering; BimObjectCategory (BO_bocat): Road Accessories; BimObjectCategoryCode (BO_bocat_code): road-accessories; IfcClassification (BO_ifcclas): Electrical Element; Uniclass14Code (BO_uniclass_1_4_code): L44; Uniclass14Description (BO_uniclass_1_4_desc): Barriers; Uniclass20Code (BO_uniclass_2_0_code): PR-16-17-08; Uniclass20Description (BO_uniclass_2_0_desc): Barrier Parking Controllers; Uniclass2015Code (BO_uniclass2015_code): Pr_40_70_22_06; Uniclass2015Description (BO_uniclass2015_desc): Barrier parking control units; NBSReference (BO_nbs_ref): 16-17-08; NBSReferenceDescription (BO_nbs_desc): Barrier Parking Controllers; OmniClassCode (BO_omniclass_code): 23-39 11 11 15; OmniClassDescription (BO_omniclass_name): Traffic Barriers; MasterFormat2014Code (BO_masterformat2014_code): 01 55 00; MasterFormat2014Description (BO_masterformat2014_name): Vehicular Access and Parking; RegionEurope (BO_europe): AL, AT, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FR, GB, GR, HR, HU, IE, IS, IT, LT, LU, LV, MD, ME, MK, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, UA; RegionNorthAmerica (BO_northamerica): BS, BZ, CA, CR, CU, DO, GL, GT, HN, HT, JM, MX, NI, PA, PR, SV, TT, US; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CN, GE, ID, IN, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MY, NP, PH, PK, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AU, FJ, NC, NZ, PG, SB, TL, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, LR, LS, LY, MA, MG, ML, MR, MW, MZ, NA, NE, NG, RW, SD, SL, SN, SO, SS, SZ, TD, TG, TN, TZ, UG, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): TF
